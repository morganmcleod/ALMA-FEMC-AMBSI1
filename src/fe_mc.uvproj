# Keil uVision project fe_mc.uvproj, settings and files
target AMBSI Flash Small (166/167)
  device: C167CR-LM Infineon
  cpu: IRAM(0xF600-0xFDFF) XRAM(0xE000-0xE7FF) ICAN(0xE800-0xEFFF) CLOCK(20000000) MOD167
  output: fe_mc_small +hex
  group Source
    ./: main.c
  group Startup
    ./: START167.A66
  group Libraries
    ../libraries/ds1820/: ds1820ambsismall.LIB
    ../libraries/amb/: ambambsismall.LIB
  group Text
    ../: Release History.txt
target Monitor (166/167)
  device: C167CR-LM Infineon
  cpu: IRAM (0xF600 - 0xFDFF) XRAM(0xE000-0xE7FF) ICAN(0xE800-0xEFFF) CLOCK(20000000) MOD167
  output: fe_mc
