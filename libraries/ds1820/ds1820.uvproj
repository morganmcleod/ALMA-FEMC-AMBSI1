# Keil uVision project ds1820.uvproj, settings and files
target SK167hl (166/167)
  device: C167CR-LM Siemens
  cpu: IRAM (0xF600 - 0xFDFF) XRAM(0xE000-0xE7FF) ICAN(0xE800-0xEFFF) CLOCK(20000000) MOD167
  output: ds1820sk167hl (library)
  group Source
    ./: ds1820.c
target AMBSIhl (166/167)
  device: C167CR-LM Siemens
  cpu: as above
  output: ds1820ambsihl (library)
target SK167s (166/167)
  device: C167CR-LM Siemens
  cpu: as above
  output: ds1820sk167s (library)
target AMBSIs (166/167)
  device: C167CR-LM Siemens
  cpu: as above
  output: ds1820ambsis (library)
target AMBSI small (166/167)
  device: C167CR-LM Infineon
  cpu: IRAM(0xF600-0xFDFF) XRAM(0xE000-0xE7FF) ICAN(0xE800-0xEFFF) CLOCK(20000000) MOD167
  output: ds1820ambsismall (library)
