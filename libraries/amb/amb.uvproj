# Keil uVision project amb.uvproj, settings and files
target ambsk167s (166/167)
  device: C167CR-LM Siemens
  cpu: IRAM (0xF600 - 0xFDFF) XRAM(0xE000-0xE7FF) ICAN(0xE800-0xEFFF) CLOCK(20000000) MOD167
  output: ambsk167s (library)
  group source
    ./: amb.c spi_pic.c
target ambsk167hl (166/167)
  device: C167CR-LM Siemens
  cpu: as above
  output: ambsk167hl (library)
target ambambsis (166/167)
  device: C167CR-LM Siemens
  cpu: as above
  output: ambambsis (library)
target ambambsihl (166/167)
  device: C167CR-LM Siemens
  cpu: as above
  output: ambambsihl (library)
target pictest (166/167)
  device: C167CR-LM Siemens
  cpu: as above
  output: ambambsis (library)
target amb ambsi small (166/167)
  device: C167-LM Infineon
  cpu: IRAM(0xF600-0xFDFF) CLOCK(20000000) MOD167
  output: ambambsismall (library)
